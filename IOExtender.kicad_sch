File: IOExtender.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Finished board design, outputs generated
Other:
- note added: "${RESULT}"
